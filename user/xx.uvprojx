# Keil uVision project xx.uvprojx, settings and files
target project (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: xx +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_XL,USE_STDPERIPH_DRIVER
  c include: ..\user;..\FWLIB\inc;..\head;..\Core;..\App
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group user
    ./: main.c main_app.c pct_app.c crc16.c
  group lib
    ../lib/: 四通道驱动板.lib
  group app
    ../App/: MotionDispatch.c
